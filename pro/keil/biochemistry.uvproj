# Keil uVision project biochemistry.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: biochemistry +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\sys;..\..\app;..\..\hal
  asm include: ..\sys;..\app;..\hal
  group Hal
    ./: STARTUP.A51
    ../../hal/: Hal.c
  group App
    ../../app/: main.c motor.c mproto.c
  group Sys
    ../../sys/: sys.c
